# Keil uVision project USBHIDBattery.uvproj, settings and files
target Target (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: USBHIDBattery +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group
    ./Lib/: Debug.C
    ./: USBHIDBattery.C HID_DEFINES.h USBDesc.h
